# IAR project S32K1xx.ewp, settings and files
configuration S32K146 (ARM, debug)
  General.OGChipSelectEditMenu: S32K146 NXP S32K146
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __Target_S32K146__
  ICCARM.CCIncludePath2: $PROJ_DIR$; F:\Project.Software\Master.System\Master.OS\Includes; F:\Project.Software\Master.System\Master.Drivers\Master.Drivers.S32K1xx\Includes
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S32K1xx.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: F:\Project.Software\Master.System\Master.OS\Config\S32K146.icf
  ILINK.IlinkExtraOptions: --whole_archive F:\Project.Software\Master.System\Master.BSP\Master.BSP.S32K1xx\Release.Library\Master.BSP.S32K146.a; --whole_archive F:\Project.Software\Master.System\Master.OS\Release.Library\Master.OS.ARM.V7.M4.a; --whole_archive F:\Project.Software\Master.System\Master.Drivers\Master.Drivers.S32K1xx\Release.Library\Master.Drivers.S32K146.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S32K148 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S32K148 NXP S32K148
  ICCARM.CCDefines: __Target_S32K148__
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: F:\Project.Software\Master.System\Master.OS\Config\S32K148.icf
  ILINK.IlinkExtraOptions: --whole_archive F:\Project.Software\Master.System\Master.BSP\Master.BSP.S32K1xx\Release.Library\Master.BSP.S32K148.a; --whole_archive F:\Project.Software\Master.System\Master.OS\Release.Library\Master.OS.ARM.V7.M4.a; --whole_archive F:\Project.Software\Master.System\Master.Drivers\Master.Drivers.S32K1xx\Release.Library\Master.Drivers.S32K148.a
  group (top)
    ./: main.c
